# meta-java does some gcc version specific compile flags. Since Arch
# is on GCC 9 now, set this variable so we build right.
FLAGS_GCC9 = "${FLAGS_GCC8}"
