CFLAGS_append = " -fcommon"
