# remove implicit fallthrough warning on gcc7
EXTRA_OECONF += "--disable-werror"
