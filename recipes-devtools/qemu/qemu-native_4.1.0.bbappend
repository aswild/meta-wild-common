FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://linux-user-remove-host-stime-syscall.patch"
