# xfsprogs tries to be clever and installs to /lib and /sbin if exec_prefix=/usr
inherit fix-usrmerge
