# I'm pretty sure I don't need systemd-userdbd.service running
PACKAGECONFIG:remove = "userdb"
