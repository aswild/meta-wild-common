# license not picked up by pipoe
LICENSE = "GPL-2.0-only"
