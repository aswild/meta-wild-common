FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-linux-user-Do-not-define-struct-sched_attr-if-libc-h.patch"
