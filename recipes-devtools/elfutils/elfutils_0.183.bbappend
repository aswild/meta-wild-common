FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-elflint.c-Don-t-dereference-databits-if-bad.patch"
