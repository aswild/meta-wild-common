FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-Fix-packed-not-aligned-error-on-GCC-8.patch"
