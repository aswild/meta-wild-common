## conf/distro/include/no-graphics.inc
```bitbake
DISTRO_FEATURES:remove = "x11 alsa"
MACHINE_FEATURES:remove = "alsa"
DISTRO_FEATURES_OPTED_OUT:append = " pulseaudio"
```
