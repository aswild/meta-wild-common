FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://1000-fix-bsearch-macro.patch"
