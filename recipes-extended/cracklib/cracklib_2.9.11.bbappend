FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://1000-fix-gcc14-compile-error.patch"
