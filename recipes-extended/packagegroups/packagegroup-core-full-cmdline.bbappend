# I want systemd timers, not cron
RDEPENDS:packagegroup-core-full-cmdline-sys-services:remove = "cronie"
