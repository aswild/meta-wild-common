# overwrite gtk2 gui option with gtk3
PACKAGECONFIG[gtkgui] = "--enable-gui=gtk3,--enable-gui=no,gtk+3,"
