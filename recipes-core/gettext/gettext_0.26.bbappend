FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://1000-c23-build.patch"
