FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://1000-libffi-implicit-func-decl.patch"
