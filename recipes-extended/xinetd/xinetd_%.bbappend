# no need to autostart a useless xinetd service
SYSTEMD_AUTO_ENABLE = "disable"
