# don't auto-start atd (which is pulled in by packagegroup-core-full-cmdline)
SYSTEMD_AUTO_ENABLE = "disable"
