FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI += "file://0001-lsfd-fix-bsearch-macro-usage-with-glibc-C23.patch"
