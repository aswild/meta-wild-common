EXTRA_OECONF:remove = "--enable-newline-is-lf"
EXTRA_OECONF += " \
    --enable-newline-is-anycrlf \
    --enable-jit \
"
