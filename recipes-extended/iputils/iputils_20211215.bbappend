# don't enable rdisc.service
SYSTEMD_AUTO_ENABLE = "disable"
