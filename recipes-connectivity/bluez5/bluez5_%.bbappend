# don't start bluetooth.service at boot
SYSTEMD_AUTO_ENABLE = "disable"
