FILESEXTRAPATHS_prepend := "${THISDIR}/files:"
PATCHES_URI += "file://glibc-2.32-sysctl.patch"
